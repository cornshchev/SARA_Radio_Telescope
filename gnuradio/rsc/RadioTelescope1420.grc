options:
  parameters:
    generate_options: qt_gui
    id: RadioTelescope1420
    output_language: python
    title: RadioTelescop1420
  states: {}

blocks:
- name: bit_max
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: calibration_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: gui_tab@0:[1,6,3,4]
    label: Calibration Mode
    label0: Calibration off
    label1: Static Calibration
    label2: Dynamic Calibration
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: db_enabled
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: gui_tab@0:[10,15,1,1]
    label: Enable dB
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: gui_tab@0:[0,10,1,6]
    label: freq
    rangeType: int
    start: '1418000000'
    step: '1000'
    stop: '1445000000'
    value: source_freq
  states: {}
- name: freq_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: gui_tab@0:[3,12,1,4]
    label: Frequence Correction
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: integration_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: gui_tab@0:[2,10,2,2]
    label: Integration Mode
    label0: Moving Average
    label1: IIR Average
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: integration_time
  id: variable_qtgui_range
  parameters:
    gui_hint: gui_tab@0:[2,12,1,4]
    label: Interation Time(s)
    start: '1'
    step: '1'
    stop: '20'
    value: '5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: gui_tab@0:[1,10,1,6]
    label: RF Gain(dB)
    start: '0'
    step: '1'
    stop: '21'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: source_freq
  id: variable
  parameters:
    value: '1420400000'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: yroll
  id: variable_qtgui_range
  parameters:
    gui_hint: gui_tab@0:[10,7,1,7]
    label: roll
    min_len: '5'
    start: '-1000'
    step: 0.05*yzoom
    stop: '1000'
    value: '0'
    widget: slider
  states: {}
- name: yzoom
  id: variable_qtgui_range
  parameters:
    gui_hint: gui_tab@0:[10,0,1,7]
    label: zoom
    min_len: '5'
    start: '1'
    step: '1'
    stop: '1000'
    value: '10'
    widget: slider
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_length
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: db_enabled
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class spectrum_integrator(gr.sync_block):
          """
          频谱积分器块
          输入: 浮点向量 (频谱数据)
          输出: 积分后的复数向量
          """
          def __init__(self, vec_length=1024, integration_time=1.0, mode=0, samp_rate=1.0):
              gr.sync_block.__init__(
                  self,
                  name="Spectrum Integrator",
                  in_sig=[(np.float32, vec_length)],
                  out_sig=[(np.float32, vec_length)]
              )
              
              # 参数初始化
              self.vec_length = vec_length
              self.integration_time = integration_time
              self.mode = mode
              self.samp_rate = samp_rate
              
              # 状态变量
              self.reset_state()
              
              # 上一次的参数值，用于检测变化
              self.last_integration_time = integration_time
              self.last_mode = mode
              self.last_samp_rate = samp_rate
              
          def reset_state(self):
              """重置积分器状态"""
              if self.mode == 0:
                  # 移动平均模式：需要存储多个历史帧
                  self.n_frames = max(1, int(self.integration_time * self.samp_rate / self.vec_length))
                  self.buffer = np.zeros((self.n_frames, self.vec_length), dtype=np.float32)
                  self.buffer_index = 0
                  self.buffer_count = 0
              else:  # IIR模式
                  # IIR滤波器系数
                  alpha = 1.0 / max(1.0, self.integration_time * self.samp_rate / self.vec_length)
                  self.alpha = alpha
                  self.state = np.zeros(self.vec_length, dtype=np.float32)
              
          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # 检查参数是否发生变化
              if (self.integration_time != self.last_integration_time or 
                  self.mode != self.last_mode or 
                  self.samp_rate != self.last_samp_rate):
                  self.reset_state()
                  self.last_integration_time = self.integration_time
                  self.last_mode = self.mode
                  self.last_samp_rate = self.samp_rate
              
              nframes = len(in0)
              
              if self.mode == 0:
                  # 更高效的移动平均实现
                  for i in range(nframes):
                      self.buffer[self.buffer_index] = in0[i]
                      self.buffer_index = (self.buffer_index + 1) % self.n_frames
                      
                      if self.buffer_count < self.n_frames:
                          self.buffer_count += 1
                          # 增量更新平均值
                          if self.buffer_count == 0:
                              out[i] = in0[i]
                          else:
                              out[i] = out[i-1] + (in0[i] - out[i-1]) / self.buffer_count
                      else:
                          # 缓冲区满，使用滑动窗口平均
                          out[i] = out[i-1] + (in0[i] - self.buffer[self.buffer_index]) / self.n_frames
              else:  # IIR模式
                  # 使用NumPy的向量化操作
                  alpha = self.alpha
                  one_minus_alpha = 1.0 - alpha
                  
                  # 批量处理所有帧
                  for i in range(nframes):
                      out[i] = alpha * in0[i] + one_minus_alpha * (self.state if i == 0 else out[i-1])
                  
                  self.state = out[-1]  # 只更新一次状态
              
              return nframes

          def set_integration_time(self, integration_time):
              """设置积分时间"""
              self.integration_time = integration_time
              
          def set_mode(self, mode):
              """设置积分模式"""
              self.mode = mode
              
          def set_samp_rate(self, samp_rate):
              """设置采样率"""
              self.samp_rate = samp_rate
    integration_time: integration_time
    mode: integration_mode
    samp_rate: samp_rate/4
    vec_length: vec_length
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matplotlib.pyplot as plt
      from PyQt5.QtWidgets import QFileDialog
      from gnuradio import gr
      import os

      class save_spectrum_image(gr.sync_block):
          """
          Block to save spectrum image when triggered by a Qt GUI Push Button.
          """
          def __init__(self, vec_length=1024, x_axis_start_value=0, x_axis_step_value=1,
                       x_axis_label="Frequency", y_axis_label="Magnitude",
                       x_axis_units="Hz", y_axis_units="dB",
                       y_min=-120, y_max=0):
              gr.sync_block.__init__(
                  self,
                  name="Save Spectrum Image",
                  in_sig=[np.float32],
                  out_sig=None
              )
              
              self.vec_length = vec_length
              self.x_axis_start_value = x_axis_start_value
              self.x_axis_step_value = x_axis_step_value
              self.x_axis_label = x_axis_label
              self.y_axis_label = y_axis_label
              self.x_axis_units = x_axis_units
              self.y_axis_units = y_axis_units
              self.y_min = y_min
              self.y_max = y_max
              
              self.message_port_register_in(gr.pmt.intern("save"))
              self.set_msg_handler(gr.pmt.intern("save"), self.handle_save_msg)
              
              self.data_buffer = np.zeros(vec_length)
              self.buffer_ready = False
              
          def work(self, input_items, output_items):
              in_data = input_items[0]
              
              # Only store the most recent data
              if len(in_data) >= self.vec_length:
                  self.data_buffer = in_data[-self.vec_length:]
                  self.buffer_ready = True
              elif len(in_data) > 0:
                  # Handle case where we get partial data (shouldn't happen with sync block)
                  self.data_buffer = np.roll(self.data_buffer, -len(in_data))
                  self.data_buffer[-len(in_data):] = in_data
                  self.buffer_ready = True
                  
              return len(input_items[0])
          
          def handle_save_msg(self, msg):
              if not self.buffer_ready:
                  print("No data available to save yet.")
                  return
                  
              # Get save path from user
              options = QFileDialog.Options()
              file_path, _ = QFileDialog.getSaveFileName(
                  None,
                  "Save Spectrum Image",
                  "",
                  "PNG Files (*.png);;All Files (*)",
                  options=options
              )
              
              if not file_path:
                  return  # User cancelled
                  
              # Add .png extension if not present
              if not file_path.lower().endswith('.png'):
                  file_path += '.png'
                  
              # Generate x-axis values
              x_values = np.arange(
                  self.x_axis_start_value,
                  self.x_axis_start_value + self.vec_length * self.x_axis_step_value,
                  self.x_axis_step_value
              )
              
              # Create and save plot
              plt.figure(figsize=(10, 6))
              plt.plot(x_values, self.data_buffer)
              plt.xlabel(f"{self.x_axis_label} ({self.x_axis_units})")
              plt.ylabel(f"{self.y_axis_label} ({self.y_axis_units})")
              plt.title("Spectrum")
              plt.grid(True)
              
              # Set axis limits if specified
              if self.y_min is not None:
                  plt.ylim(bottom=self.y_min)
              if self.y_max is not None:
                  plt.ylim(top=self.y_max)
                  
              plt.tight_layout()
              plt.savefig(file_path, dpi=300)
              plt.close()
              
              print(f"Spectrum image saved to: {file_path}")
    vec_length: vec_length
    x_axis_label: '"Frequency"'
    x_axis_start_value: (freq-samp_rate/decimation/2)/1e6
    x_axis_step_value: (samp_rate/decimation/vec_length)/1e6
    x_axis_units: '"MHz"'
    y_axis_label: '"Average Signal"'
    y_axis_units: '''dB'''
    y_max: yroll+1000/yzoom
    y_min: yroll-1000/yzoom
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: gui_tab
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum
    label1: Record
    label2: Calibration
    num_tabs: '3'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0"'
    bb_gain0: '0'
    corr0: freq_corr
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '40'
    channel: '0'
    decim: decimation
    fft_filts: 'False'
    fft_rot: 'False'
    taps: '[-0.00010077140177600086,3.744094076378371e-18,0.00010225032747257501,0.0001928186829900369,0.0002597580896690488,0.00029382319189608097,0.000289677846012637,0.0002466746373102069,0.00016909977421164513,6.583039066754282e-05,-5.0583734264364466e-05,-0.00016533579037059098,-0.00026313215494155884,-0.00033012282801792026,-0.00035576397203840315,-0.0003343744028825313,-0.00026616855757310987,-0.00015759572852402925,-2.0890498490189202e-05,0.0001271671208087355,0.0002671798865776509,0.0003795491938944906,0.0004470957210287452,0.0004575501661747694,0.00040556868771091104,0.00029396190075203776,0.0001339077716693282,-5.5962584156077355e-05,-0.0002515707165002823,-0.0004262994334567338,-0.0005544746527448297,-0.0006149832624942064,-0.0005945363081991673,-0.0004900945932604373,-0.0003100538451690227,-7.392675615847111e-05,0.000189549449714832,0.0004457355826161802,0.0006584867369383574,0.0007950858562253416,0.0008310627308674157,0.0007542108069173992,0.0005671796971000731,0.00028817192651331425,-5.04916170029901e-05,-0.0004058895574416965,-0.000729755440261215,-0.0009748543961904943,-0.001101661822758615,-0.0010844252537935972,-0.0009157112799584866,-0.0006086961948312819,-0.00019672000780701637,0.0002700166078284383,0.0007303403108380735,0.0011199230793863535,0.0013800577726215124,0.0014662218745797873,0.0013552122982218862,0.0010497546754777431,0.0005797845660708845,-1.471207555619054e-17,-0.0006161980563774705,-0.0011857599020004272,-0.0016269513871520758,-0.0018708114512264729,-0.0018715295009315014,-0.0016142255626618862,-0.0011188883800059557,-0.0004396907170303166,0.0003404956660233438,0.0011199063155800104,0.0017908948939293623,0.0022545214742422104,0.002434777794405818,0.002290444914251566,0.001822799677029252,0.0010778607102110982,0.00014255345740821213,-0.0008650132222101092,-0.0018101362511515617,-0.0025592176243662834,-0.0029982891865074635,-0.003049836726859212,-0.0026855035685002804,-0.001932682585902512,-0.0008737613097764552,0.0003622721997089684,0.001615110319107771,0.002713544527068734,0.003498471574857831,0.0038454467430710793,0.0036836452782154083,0.0030084303580224514,0.0018854588270187378,0.0004453219298738986,-0.001131025841459632,-0.0026345201767981052,-0.0038552533369511366,-0.004611252341419458,-0.004774898290634155,-0.0042932238429784775,-0.0031990045681595802,-0.0016106439288705587,0.0002796905755531043,0.002228643512353301,0.003972405567765236,0.005261801183223724,0.00589714152738452,0.00575806200504303,0.0048240129835903645,0.003182128304615617,0.0010207775048911572,-0.0013910436537116766,-0.0037363660521805286,-0.005691098980605602,-0.006967911962419748,-0.0073573230765759945,-0.006760253105312586,-0.0052071912214159966,-0.002860687207430601,3.61133158806361e-17,0.0030109172221273184,0.005768586881458759,0.00788287352770567,0.009030761197209358,0.009003815241158009,0.007742572575807571,0.00535252969712019,0.0020986301824450493,-0.001622132956981659,-0.005327435210347176,-0.008510385639965534,-0.010706890374422073,-0.011560900136828423,-0.010878674685955048,-0.008664165623486042,-0.0051297699101269245,-0.000679649121593684,0.004133662208914757,0.008675052784383297,0.012307527475059032,0.014477899298071861,0.014796378090977669,0.013099155388772488,0.009484703652560711,0.004317425191402435,-0.0018037520349025726,-0.008109875954687595,-0.013753114268183708,-0.01791430450975895,-0.01991395093500614,-0.01931246928870678,-0.015986070036888123,-0.010166900232434273,-0.0024399636313319206,0.006305685732513666,0.014968391507863998,0.02235942706465721,0.02734929695725441,0.029018204659223557,0.02679256722331047,0.020550107583403587,0.01067889854311943,-0.0019196730572730303,-0.01588793843984604,-0.029526036232709885,-0.0409533753991127,-0.048301875591278076,-0.04992091655731201,-0.04457191005349159,-0.03159036487340927,-0.0109963184222579,0.016461091116070747,0.0493323989212513,0.0855695903301239,0.12269250303506851,0.1580045372247696,0.18883630633354187,0.21279296278953552,0.22797951102256775,0.23318113386631012,0.22797951102256775,0.21279296278953552,0.18883630633354187,0.1580045372247696,0.12269250303506851,0.0855695903301239,0.0493323989212513,0.016461091116070747,-0.0109963184222579,-0.03159036487340927,-0.04457191005349159,-0.04992091655731201,-0.048301875591278076,-0.0409533753991127,-0.029526036232709885,-0.01588793843984604,-0.0019196730572730303,0.01067889854311943,0.020550107583403587,0.02679256722331047,0.029018204659223557,0.02734929695725441,0.02235942706465721,0.014968391507863998,0.006305685732513666,-0.0024399636313319206,-0.010166900232434273,-0.015986070036888123,-0.01931246928870678,-0.01991395093500614,-0.01791430450975895,-0.013753114268183708,-0.008109875954687595,-0.0018037520349025726,0.004317425191402435,0.009484703652560711,0.013099155388772488,0.014796378090977669,0.014477899298071861,0.012307527475059032,0.008675052784383297,0.004133662208914757,-0.000679649121593684,-0.0051297699101269245,-0.008664165623486042,-0.010878674685955048,-0.011560900136828423,-0.010706890374422073,-0.008510385639965534,-0.005327435210347176,-0.001622132956981659,0.0020986301824450493,0.00535252969712019,0.007742572575807571,0.009003815241158009,0.009030761197209358,0.00788287352770567,0.005768586881458759,0.0030109172221273184,3.61133158806361e-17,-0.002860687207430601,-0.0052071912214159966,-0.006760253105312586,-0.0073573230765759945,-0.006967911962419748,-0.005691098980605602,-0.0037363660521805286,-0.0013910436537116766,0.0010207775048911572,0.003182128304615617,0.0048240129835903645,0.00575806200504303,0.00589714152738452,0.005261801183223724,0.003972405567765236,0.002228643512353301,0.0002796905755531043,-0.0016106439288705587,-0.0031990045681595802,-0.0042932238429784775,-0.004774898290634155,-0.004611252341419458,-0.0038552533369511366,-0.0026345201767981052,-0.001131025841459632,0.0004453219298738986,0.0018854588270187378,0.0030084303580224514,0.0036836452782154083,0.0038454467430710793,0.003498471574857831,0.002713544527068734,0.001615110319107771,0.0003622721997089684,-0.0008737613097764552,-0.001932682585902512,-0.0026855035685002804,-0.003049836726859212,-0.0029982891865074635,-0.0025592176243662834,-0.0018101362511515617,-0.0008650132222101092,0.00014255345740821213,0.0010778607102110982,0.001822799677029252,0.002290444914251566,0.002434777794405818,0.0022545214742422104,0.0017908948939293623,0.0011199063155800104,0.0003404956660233438,-0.0004396907170303166,-0.0011188883800059557,-0.0016142255626618862,-0.0018715295009315014,-0.0018708114512264729,-0.0016269513871520758,-0.0011857599020004272,-0.0006161980563774705,-1.471207555619054e-17,0.0005797845660708845,0.0010497546754777431,0.0013552122982218862,0.0014662218745797873,0.0013800577726215124,0.0011199230793863535,0.0007303403108380735,0.0002700166078284383,-0.00019672000780701637,-0.0006086961948312819,-0.0009157112799584866,-0.0010844252537935972,-0.001101661822758615,-0.0009748543961904943,-0.000729755440261215,-0.0004058895574416965,-5.04916170029901e-05,0.00028817192651331425,0.0005671796971000731,0.0007542108069173992,0.0008310627308674157,0.0007950858562253416,0.0006584867369383574,0.0004457355826161802,0.000189549449714832,-7.392675615847111e-05,-0.0003100538451690227,-0.0004900945932604373,-0.0005945363081991673,-0.0006149832624942064,-0.0005544746527448297,-0.0004262994334567338,-0.0002515707165002823,-5.5962584156077355e-05,0.0001339077716693282,0.00029396190075203776,0.00040556868771091104,0.0004575501661747694,0.0004470957210287452,0.0003795491938944906,0.0002671798865776509,0.0001271671208087355,-2.0890498490189202e-05,-0.00015759572852402925,-0.00026616855757310987,-0.0003343744028825313,-0.00035576397203840315,-0.00033012282801792026,-0.00026313215494155884,-0.00016533579037059098,-5.0583734264364466e-05,6.583039066754282e-05,0.00016909977421164513,0.0002466746373102069,0.000289677846012637,0.00029382319189608097,0.0002597580896690488,0.0001928186829900369,0.00010225032747257501,3.744094076378371e-18,-0.00010077140177600086]'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: bit_max
    grid: 'True'
    gui_hint: gui_tab@0:[0,0,4,4]
    legend: 'False'
    name: '"Signal Histogram"'
    size: int(samp_rate/8)
    type: float
    xmax: '0.5'
    xmin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    gui_hint: gui_tab@0:[11,0,10,16]
    label1: Spectrum
    name: '"Average Spectrum"'
    vlen: vec_length
    width1: '2'
    x_axis_label: '"Frequency"'
    x_start: (freq-samp_rate/decimation/2)/1e6
    x_step: (samp_rate/decimation/vec_length)/1e6
    x_units: '"MHz"'
    y_axis_label: '"Average Signal"'
    y_units: '"Amp/dB"'
    ymax: yroll+1000/yzoom
    ymin: yroll-1000/yzoom
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    gui_hint: gui_tab@0:[4,0,6,16]
    name: '"Waterfall Spectrum"'
    type: complex
  states: {}
- name: spectrum_save
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: gui_tab@0:[0,6,1,4]
    label: Save Spectum
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_selector_0, '0', qtgui_vector_sink_f_0_0_1_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', epy_block_1, '0']
- [epy_block_0, '0', blocks_nlog10_ff_0, '0']
- [epy_block_0, '0', blocks_selector_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', pfb_decimator_ccf_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pfb_decimator_ccf_0, '0', blocks_stream_to_vector_0_0, '0']
- [spectrum_save, pressed, epy_block_1, save]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
